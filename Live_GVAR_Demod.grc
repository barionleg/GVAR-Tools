options:
  parameters:
    author: Xerbo (modified from Aang23)
    generate_options: no_gui
    id: livegvardemod
    output_language: python
    title: G13 Live GVAR Demodulator
  states: {}

blocks:
- name: clock_alpha
  id: variable
  parameters:
    value: '8.7e-3'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1685.7e6
  states: {}
- name: pll_alpha
  id: variable
  parameters:
    value: '0.002'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symbol_rate*1.0)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '2111360'
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '4000'
    rate: '0.0010e-3'
    reference: '1'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 128*8
    type: byte
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '13615'
    psize: '1024'
    type: complex
    vlen: '128'
  states: {}
- name: blocks_unpacked_to_packed_xx_2
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: clock_alpha
    gain_omega: clock_alpha**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: pll_alpha
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: symbol_rate * 2
    decim: '2'
    gain: '1'
    samp_rate: samp_rate*2
    type: fir_filter_ccf
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: note_0_0
  id: note
  parameters:
    note: RTLSDR
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"airspy=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_1
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '40'
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '40'
    iq_balance_mode0: '1'
    sample_rate: samp_rate*2
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    name: '"Out depunctured"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.7'
    decim: '1'
    gain: '1'
    ntaps: '361'
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: sdr_input
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sdr_input
  states: {}

connections:
- [analog_agc_xx_0_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_complex_to_float_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_udp_sink_0, '0']
- [blocks_unpacked_to_packed_xx_2, '0', blocks_stream_to_vector_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_unpacked_to_packed_xx_2, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', root_raised_cosine_filter_0, '0']
- [osmosdr_source_0, '0', virtual_sink_0_0, '0']
- [osmosdr_source_0_1, '0', low_pass_filter_0_1, '0']
- [root_raised_cosine_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [virtual_source_0, '0', analog_agc_xx_0_0, '0']

metadata:
  file_format: 1
